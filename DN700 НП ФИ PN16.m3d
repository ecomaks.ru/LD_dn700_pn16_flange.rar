# KOMPAS-3D part (DN700 НП ФИ PN16.m3d)

Model tree:
1. Операция без истории:1

Texts:
  DN700 НП ФИ PN16